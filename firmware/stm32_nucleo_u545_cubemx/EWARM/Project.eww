<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_nucleo_u545_cubemx.ewp</path>
  </project>
  <batchBuild />
</workspace>
